DESCRIPTION = "Packages for pcDuino boards"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = "\
    pcduino-tools \
    "
